/* Server Program demonstrating set up for client/server communications */
/* within a single computer using port number provided by user          */

#include <stdio.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <netdb.h> 
#include <unistd.h>
#include <string.h>
#include <stdlib.h>


int main(int argc, char *argv[])
{
     /* port numbers for communications */
     int sockfd, newsockfd, portnumber, client_len;
     char buffer[256], newbuf[256] = "Server recieved message: ";

     /* structure containing internet address */
     struct sockaddr_in server_addr, client_addr;
     int n;

     /* get port number */
     if (argc < 2) {
         fprintf(stderr,"ERROR: No port\n");
         exit(1);
     }

     /* create new socket of type TCP */
     sockfd = socket(AF_INET, SOCK_STREAM, 0);
     if (sockfd < 0) 
        printf("ERROR: Cannot open socket");
 
     /*  xero values in buffer  */
     memset (&server_addr, 0, sizeof(server_addr));

     /* convert to number */
     portnumber = atoi(argv[1]);

     /* set address family */
     server_addr.sin_family = AF_INET;

     /* set address of server machine  */
     server_addr.sin_addr.s_addr = INADDR_ANY;

     /* put port number into network byte order */
     server_addr.sin_port = htons(portnumber);

     /* bind socket to an address – fd, current host&port, length */
     if (bind(sockfd, (struct sockaddr *) &server_addr,
              sizeof(server_addr)) < 0) 
              printf("ERROR: Cannot bind");

     /* listen on port with backlog of 5  */
     listen(sockfd,5);

     /* accept new connections        */
     /* block until a connect returns */
     /* return file descriptor        */
     client_len = sizeof(client_addr);
     
     newsockfd = accept(sockfd, (struct sockaddr *) &client_addr,(unsigned int *) &client_len);
     if (newsockfd < 0) 
          printf("ERROR: On accept");
     
     while(strcmp(buffer, "exit") != 0)
     {
     	/* read data in from socket and print result */ 
     	memset(buffer,0, 256);  /* clear buffer  */
     
     	/*read message from socket*/
    	n = read(newsockfd, buffer, 255);
    	
    	strcat(newbuf, buffer);
    	
    	if (n < 0) printf("ERROR: Cannot read from socket");
     	printf("%s\n",newbuf);
     	
     	/*write message to socket*/	
		n = write(newsockfd, newbuf,strlen(newbuf));
		if (n < 0)
			printf("ERROR: Cannot write to socket\n");
		strcpy(newbuf, "Server recieved message: ");
     	
     }
     
     return 0; 
}
